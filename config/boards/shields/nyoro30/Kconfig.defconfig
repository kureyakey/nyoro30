## config/boards/shields/nyoro30/Kconfig.defconfig
```kconfig
if SHIELD_NYORO30
  config ZMK_KEYBOARD_NAME
  default "nyoro30"
endif

config SPI
    default y
```
